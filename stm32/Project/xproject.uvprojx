# Keil uVision project xproject.uvprojx, settings and files
target OpenCTR (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: xproject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\Robot;..\System;..\Driver\DRIVE;..\Driver\ENCODER;..\Driver\KINEMATICS;..\Driver\MOTOR;..\Driver\CONTROL;..\Driver\USART3;..\Driver\USART2;..\Driver\USART6;..\Driver\DMA;..\Driver\AS7341;..\Driver\KEY;..\Driver\SEVOR;..\Driver\UART4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Robot
    ../Robot/: main.c stm32f4xx_it.c system_stm32f4xx.c FreeRTOSConfig.h robot.c
  group Libraries
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group Doc
    ../Doc/: readme.txt
  group Drive
    ../Driver/AS7341/: as7341.c
    ../Driver/DRIVE/: drive.c
    ../Driver/ENCODER/: encoder.c
    ../Driver/KINEMATICS/: kinematics.c
    ../Driver/MOTOR/: motor.c
    ../Driver/CONTROL/: control.c
    ../Driver/DMA/: dma.c
    ../Driver/USART2/: usart2.c
    ../Driver/USART3/: usart3.c
    ../Driver/USART6/: usart6.c
    ../Driver/KEY/: key.c
    ../Driver/SEVOR/: LobotServoController.c
    ../Driver/UART4/: uart4.c
  group System
    ../System/: delay.c sys.c usart.c
